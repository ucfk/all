	ORG 0000H
	JMP START

	ORG 0100H
START:
	MOV SP,#3FH
	CLR EA

	MOV TMOD,#20H
	MOV SCON,#50H
	MOV TH1,#0FDH
	MOV TL1,#0FDH
	SETB TR1

	MOV R7,#11

LOOP10:
	MOV DPTR,#MSG1
	ACALL SEND_STRING

	ACALL DELAY500
	DJNZ R7,LOOP10

	MOV DPTR,#MSG2
	ACALL SEND_STRING

STOP:	SJMP STOP

SEND_STRING:
	CLR A
NEXT:
	MOVC A,@A+DPTR
	JZ DONE
	ACALL SEND_CHAR
	INC DPTR
	CLR A
	SJMP NEXT
DONE:
	RET

SEND_CHAR:
	MOV SBUF,A
WAIT:
	JNB TI,WAIT
	CLR TI
	RET

DELAY500:
	MOV R5,#20
D1:	MOV R6,#250
D2:	MOV R4,#250
D3:	DJNZ R4,D3
	DJNZ R6,D2
	DJNZ R5,D1
	RET

MSG1:	DB 'B6705787 Patchareeya Mekprayoon',0
MSG2:	DB 'I Want A',0

	END