 ORG 0000H 
 JMP 0100H 
 ORG 0100H 
 CLR EA 
 MOV SP,#02FH 
 SETB P3.0 
 CLR P3.1 
 MOV R7,#00 
 MOV DPTR,#Seg_Table
M_LOOP: 
	MOV A,R7 
	ANL A,#0FH 
	MOVC A,@A+DPTR 
	CPL A 
	MOV P1,A 
	CPL P3.0 
	CPL P3.1 
	INC R7 
	CALL DELAY 
	JMP M_LOOP
Seg_Table: 
	DB 7CH, 00H, 7DH, 00H 
	db 07H, 00H, 5BH, 00H 
	DB 7FH, 00H, 07H, 00H 
	DB 6FH, 00H, 4FH, 00H
DELAY: 
	MOV R0,#3 
	CLR A 
	MOV B,A

_DLY00: 
	DJNZ B,_DLY00 
	DJNZ Acc,_DLY00 
	DJNZ R0,_DLY00 
RET 

END