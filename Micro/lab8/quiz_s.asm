	ORG	0000H
	JMP	0100H
	ORG	0100H
	
	ORL	P3,#00001111B
	MOV	A , #01H
	
LOOP_WAIT:	JNB	P3.0 , L2R_S
		JNB	P3.1 , L2R_F
		JNB	P3.2 , R2L_S
		JNB	P3.3 , R2L_F
		
L2R_S:		MOV	P1 , A
		CALL	DELAY_SLOW
		RR	A
		JMP	L2R_S
		
L2R_F:		MOV	P1 , A
		CALL	DELAY_FAST
		RR	A
		JMP	L2R_F
		
R2L_S:		MOV	P1 , A
		CALL	DELAY_SLOW
		RL	A
		JMP	R2L_S
		
R2L_F:		MOV	P1 , A
		CALL	DELAY_FAST
		RL	A
		JMP	R2L_F


DELAY_SLOW:	MOV	R7 , #250
LOOB1_S:	MOV	R6 , #250
LOOB2_S:	DJNZ	R6 , LOOB2_S
		JNB	P3.0 , L2R_S
		JNB	P3.1 , L2R_F
		JNB	P3.2 , R2L_S
		JNB	P3.3 , R2L_F
		DJNZ	R7 , LOOB1_S
		
		RET
		
DELAY_FAST:	MOV	R7 , #150
LOOB1_F:	MOV	R6 , #150
LOOB2_F:	DJNZ	R6 , LOOB2_F
		JNB	P3.0 , L2R_S
		JNB	P3.1 , L2R_F
		JNB	P3.2 , R2L_S
		JNB	P3.3 , R2L_F
		DJNZ	R7 , LOOB1_F
		
		RET
		
		END