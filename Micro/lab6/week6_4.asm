	ORG	0000H
	JMP	0100H
	ORG	0100H
	
	SETB	P1.3
	CLR	P1.7
	
LOOP:	JNB	P1.3, COUNT
	SJMP	LOOP
	
COUNT:	MOV	R7, #00

C1:	JB	P1.3, PRE
	CALL 	DELAY2
	INC	R7
	CJNE	R7, #05, C1
	SJMP	LONG

PRE:		
SHORT:	CPL	P1.7
	CALL	DELAY1
	JNB	P1.3, WAIT1
	SJMP	SHORT
WAIT1:	JNB	P1.3, WAIT1
	CLR	P1.7
	SJMP	LOOP
	
LONG:	SETB	P1.7

WAITP2:	JNB	P1.3, WAITP2
	
WAIT2:	JB	P1.3, WAIT2

	CLR	P1.7	
WAIT_R2:
	JNB	P1.3, WAIT_R2
	SJMP	LOOP
	
DELAY1:	MOV	11H, #2
D1:	MOV	A, #200
D2:	MOV	B, #200
D3:	DJNZ	B, D3
	DJNZ	Acc, D2
	DJNZ	11H, D1	
	RET

DELAY2:	MOV	11H, #10
D4:	MOV	A, #200
D5:	MOV	B, #200
D6:	DJNZ	B, D6
	DJNZ	Acc, D5
	DJNZ	11H, D4	
	RET
	
	END	